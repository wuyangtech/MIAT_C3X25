# Keil uVision project Project.uvprojx, settings and files
target MIAT-STM32F103ZE (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: miat_stm32f103x +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: VECT_TAB_FLASH
  c include: ..\..\STM32_Lib\FWLib\library\inc;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../: stm32f10x_it.c main.c fsmc_sram.c hal_miatc3x_counter.c
  group FWLib
    ../../STM32_Lib/FWLib/library/src/: stm32f10x_wwdg.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
  group RVMDK
    ./: stm32f10x_vector.s cortexm3_macro.s
  group Doc
    ./: MIAT_STM32F103ZC_README.txt MIAT_STM32F103ZC_USB_NOTE.txt
software components: CMSIS:CORE 5.0.1
